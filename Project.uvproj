# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64D4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User\inc;.\STC8Ax_LIB\inc;.\STC8Ax_LIB\core
  group STC8Ax_lib
    ./STC8Ax_LIB/src/: STC8Ax_DELAY.c STC8Ax_GPIO.c
  group User
    ./User/: main.c
    ./User/src/: System_init.c LCD1602.c Time.c KeyScan.c
